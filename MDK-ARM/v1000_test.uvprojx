# Keil uVision project v1000_test.uvprojx, settings and files
target v1000_test (ARM-ADS)
  device: STM32L151RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: T-1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c misc: --C99
  c include: ../Inc;               ../Drivers/STM32L1xx_HAL_Driver/Inc;               ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;               ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;               ../Middlewares/Third_Party/FatFs/src;               ../Middlewares/Third_Party/FreeRTOS/Source/include;               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;               ../Drivers/CMSIS/Include;               ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;               ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;               ../Drivers/BSP;               ..\Drivers\BSP\Adafruit_Shield;               ..\Drivers\BSP\GPS;               ..\Drivers\BSP\STM32L1xx_Nucleo
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l1xx_it.c fatfs.c freertos.c user_diskio.c main.c stm32l1xx_hal_msp.c usbd_desc.c usbd_storage_if.c usbd_conf.c usb_device.c stm32l1xx_hal_timebase_TIM.c menutal.c gongshi.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c croutine.c queue.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_flash.c stm32l1xx_hal.c stm32l1xx_hal_gpio.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_pcd.c stm32l1xx_hal_adc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_data.c usbd_msc_scsi.c usbd_msc_bot.c usbd_msc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group BSP
    ../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c
    ../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
    ../Drivers/BSP/GPS/: gps.c
software components: CMSIS:CORE 4.1.0
